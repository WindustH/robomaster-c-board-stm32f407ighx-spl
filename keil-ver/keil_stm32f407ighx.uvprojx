# Keil uVision project keil_stm32f407ighx.uvprojx, settings and files
target keil_stm32f407ighx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil_stm32f407ighx +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\core\CMSIS\Device\ST\STM32F4xx\Include;..\core\CMSIS\Include;..\lib;..\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../core/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
    ../core/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../core/CMSIS/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
    ../startup-mdkarm/: startup_stm32f407xx.s
  group APP
    ../src/app/: mon.c pid.c tick.c
  group BSP
    ../src/bsp/: can.c clock.c cron.c led.c motor.c uart.c uart_dma.c uart_it.c
  group UTILS
    ../src/utils/: map.c map.h modu.c modu.h
  group MOD
    ../src/mod/: app.c app.h bsp.c bsp.h err.c err.h
  group ERR
    ../src/err/: status_led.c
  group USER
    ../src/: def.h main.c type.c type.h
